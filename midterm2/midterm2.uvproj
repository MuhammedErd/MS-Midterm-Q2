# Keil uVision project midterm2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2102 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: midterm2
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Source Group 1
    ./: Startup.s midterm2.s
